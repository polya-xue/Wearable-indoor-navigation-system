# IAR project Profiles.ewp, settings and files
configuration STM32L053R8_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; SET_L2CAP_CONN_UPD_REQ_COMMAND; SET_TX_POWER_COMMAND
  ICCARM.CCIncludePath2: ..\Inc; ..\..\BlueNRG_Lib\includes; ..\..\BlueNRG_Lib\hci; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\LowPowerManager\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM_Shields\X-NUCLEO-IDB04A1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Profiles.bin
  ILINK.IlinkOutputFile: BlueNRG_Profiles.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: bluenrg_interface.c hrm_profile_application.c htl.c low_power_conf.c main.c osal.c stm32l0xx_it.c
  group Application/User/LPM
    ../../LowPowerManager/Src/: stm32xx_lpm.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c stm32l0xx_nucleo_bluenrg.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../../../../../../../Drivers/BSP/STM_Shields/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c
  group Middlewares/STM32_BlueNRG/BlueNRG_Lib
    ../../BlueNRG_Lib/: BlueNRGLib_EWARM.a
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
