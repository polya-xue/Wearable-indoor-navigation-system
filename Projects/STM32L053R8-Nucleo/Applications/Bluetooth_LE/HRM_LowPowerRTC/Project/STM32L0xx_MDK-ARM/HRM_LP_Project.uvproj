# Keil uVision project HRM_LP_Project.uvproj, settings and files
target HRM_LP-STM32L053R8_NUCLEO (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: STM32L053R8_NUCLEO +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,SET_L2CAP_CONN_UPD_REQ_COMMAND,SET_TX_POWER_COMMAND
  c misc: --C99
  c include: ..\Inc;..\..\BlueNRG_Lib\includes;..\..\BlueNRG_Lib\hci;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\LowPowerManager\Inc;..\..\..\..\..\..\..\Drivers\BSP\STM_Shields\X-NUCLEO-IDB04A1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c stm32l0xx_nucleo_bluenrg.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_it.c bluenrg_interface.c osal.c hrm_profile_application.c htl.c low_power_conf.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../../../../../../../Drivers/BSP/STM_Shields/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Application/User/LPM
    ../../LowPowerManager/Src/: stm32xx_lpm.c
  group Middlewares/STM32_BlueNRG/BlueNRG_Lib
    ../../BlueNRG_Lib/: BlueNRGLib_ARM-MDK.lib
